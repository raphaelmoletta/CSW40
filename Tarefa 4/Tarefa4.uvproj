# Keil uVision project Tarefa4.uvproj, settings and files
target AT89C151A (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Tarefa4
  c flags: Optimize=8 SizeSpeed=1
  group Ex1
    ./: main41.a51 Statechart4.1.png
  group Ex2
    ./: main42.a51 Statechart4.2.png
  group Ex3
    ./: main43.a51 Statechart4.3.png
  group Ex4
    ./: main44.a51 Statechart4.4.png
